# IAR project led_demo_freedom_0000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MK22FN512VDC12; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../targets/MK22F51212/src; ../../../../../targets/MK22F51212/src/startup; ../../../../../src/platform/devices/MK22F51212; ../../../src; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; BL_HAS_BOOTLOADER_CONFIG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: led_demo_freedom_0000.bin
  ILINK.IlinkOutputFile: led_demo_freedom_0000.elf
  ILINK.IlinkIcfFile: ../../../../../targets/common/linker/iar/MK22F51212/K22FN512xxx12_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VDC12; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM
  AARM.ADefines: NDEBUG; BL_HAS_BOOTLOADER_CONFIG
  group link
    ../../../../../targets/common/linker/iar/MK22F51212/: K22FN512xxx12_application_0x0000.icf
  group MK22F51212
    ../../src/: main.c
    ../../../src/: milliseconds_delay.c
  group src/startup
    ../../../../../src/startup/: crt0.s startup.c
    ../../../../../targets/MK22F51212/src/startup/iar/: startup_MK22F51212.s
    ../../../../../targets/MK22F51212/src/startup/: system_MK22F51212.c
