# IAR project freedom_bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 NXP MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; USB_STACK_BM; CPU_MK22FN1M0AVMC12; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM; BL_TARGET_FLASH; TURINGSENSE=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../src/startup; ..\..\..\..\src\platform\devices\MK22FA12_MK64; ../../../../src/autobaud; ../../../../src/usb/include; ../../../../src/usb/osa; ../../../../src/usb/device; ../../../../src/usb/device/class; ../../../../src/bm_usb; ../../../../src/include; ../../../../src/platform; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../src/include
  OBJCOPY.OOCOutputFile: freedom_bootloader.srec
  ILINK.IlinkOutputFile: freedom_bootloader.elf
  ILINK.IlinkIcfFile: ..\..\..\common\linker\iar\MK22FA12_MK64\K22FN1M0xxx12_application_0x0000.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; USB_STACK_BM; CPU_MK64FN1M0VMD12; CPU_IS_ARM_CORTEX_M4=1; IAR; FREEDOM; BL_TARGET_FLASH
  ICCARM.CCIncludePath2: ../../src; ../../src/startup; ../../../../src/platform/devices/MK64F12; ../../../../src/autobaud; ../../../../src/usb/include; ../../../../src/usb/osa; ../../../../src/usb/device; ../../../../src/usb/device/class; ../../../../src/bm_usb; ../../../../src/include; ../../../../src/platform; ../../../../src/platform/devices; ../../../../src/platform/CMSIS/Include; ../../../../src; ../../../../src/drivers; ../../../../src/startup; ../../../../src/drivers/common
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkIcfFile: ../../../common/linker/iar/MK64F12/K64FN1Mxxx12_application_0x0000.icf
  group k22fa12
    ../../../common/src/: bl_dspi_irq_config_common.c bl_i2c_irq_config_common.c bl_uart_irq_config_common.c pinmux_utility_common.c
    ../../src/: bootloader_config.h clock_config_MK22FA12.c hardware_init_MK22FA12.c memory_map_MK22FA12.c peripherals_MK22FA12.c peripherals_pinmux.h target_config.h
    ../../../../src/platform/devices/MK22FA12_MK64/: MK22FA12.h
  group link
    ../../../common/linker/iar/MK22FA12_MK64/: K22FN1M0xxx12_application_0x0000.icf
  group src/autobaud
    ../../../../src/autobaud/: autobaud.h
  group src/autobaud/src
    ../../../../src/autobaud/src/: autobaud_irq.c
  group src/bootloader
    ../../../../src/bootloader/: bl_app_crc_check.h bl_command.h bl_context.h bl_peripheral.h bl_peripheral_interface.h bl_shutdown_cleanup.h bl_user_entry.h bl_version.h bootloader.h
  group src/bootloader/src
    ../../../../src/bootloader/src/: bl_app_crc_check.c bl_command.c bl_context.c bl_exception_handler.c bl_main.c bl_misc.c bl_reliable_update.c bl_shutdown_cleanup.c bl_tree_root.c bl_user_entry.c dspi_peripheral_interface.c i2c_peripheral_interface.c scuart_peripheral_interface.c usb_hid_msc_peripheral_interface.c
  group src/crc
    ../../../../src/crc/: crc16.h crc32.h
  group src/crc/src
    ../../../../src/crc/src/: crc16.c crc32.c
  group src/drivers/crc
    ../../../../src/drivers/crc/: fsl_crc.c
  group src/drivers/dspi
    ../../../../src/drivers/dspi/: fsl_dspi.c
  group src/drivers/flash
    ../../../../src/drivers/flash/: fsl_flash.c fsl_flash.h
  group src/drivers/gpio
    ../../../../src/drivers/gpio/: fsl_gpio.c
  group src/drivers/i2c/src
    ../../../../src/drivers/i2c/: fsl_i2c.c
  group src/drivers/microseconds
    ../../../../src/drivers/microseconds/: microseconds.h
  group src/drivers/microseconds/src
    ../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group src/drivers/port
    ../../../../src/drivers/port/: fsl_port.h
  group src/drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group src/drivers/uart
    ../../../../src/drivers/uart/: fsl_uart.c
  group src/include
    ../../../../src/include/: bootloader_common.h
  group src/memory
    ../../../../src/memory/: memory.h
  group src/memory/src
    ../../../../src/memory/src/: device_memory.c device_memory.h flash_memory.c flash_memory.h memory.c normal_memory.c normal_memory.h pattern_fill.h pattern_fill.s sram_init_cm4.c
  group src/packet
    ../../../../src/packet/: command_packet.h serial_packet.h
  group src/packet/src
    ../../../../src/packet/src/: serial_packet.c
  group src/property
    ../../../../src/property/: property.h
  group src/property/src
    ../../../../src/property/src/: property.c
  group src/sbloader
    ../../../../src/sbloader/: sbloader.h
  group src/sbloader/src
    ../../../../src/sbloader/src/: sbloader.c
  group src/security
    ../../../../src/security/: aes128_key_wrap_unwrap.h aes_security.h cbc_mac.h
  group src/security/src
    ../../../../src/security/src/: aes128_key_wrap_unwrap.c aes_security.c cbc_mac.c
  group src/startup
    ../../../../src/startup/: crt0.s startup.c
    ../../src/startup/iar/: startup_MK22FA12.s
    ../../src/startup/: system_MK22FA12.c system_MK22FA12.h
  group src/usb/bm_composite
    ../../../../src/bm_usb/: bootloader_hid_report_ids.h composite.c composite.h fat_directory_entry.h hid_bootloader.c hid_bootloader.h msc_disk.c msc_disk.h usb_descriptor.c usb_descriptor.h
    ../../src/: usb_device_config.h
  group src/usb/device
    ../../../../src/usb/device/: usb_device.h usb_device_ch9.c usb_device_ch9.h usb_device_dci.c usb_device_dci.h usb_device_khci.c usb_device_khci.h
  group src/usb/device/calss
    ../../../../src/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_hid.c usb_device_hid.h usb_device_msc.c usb_device_msc.h usb_device_msc_ufi.c usb_device_msc_ufi.h
  group src/usb/include
    ../../../../src/usb/include/: usb.h
  group src/usb/osa
    ../../../../src/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group src/utilities
    ../../../../src/utilities/: fsl_rtos_abstraction.h
  group src/utilities/src
    ../../../../src/utilities/src/: fsl_assert.c fsl_rtos_abstraction.c
