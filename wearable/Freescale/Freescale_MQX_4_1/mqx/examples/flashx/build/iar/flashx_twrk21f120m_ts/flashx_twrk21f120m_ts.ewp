# IAR project flashx_twrk21f120m_ts.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Sources; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../../lib/twrk21f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk21f120m.iar/debug/bsp/Sources; ../../../../../../lib/twrk21f120m.iar/debug; ../../../../../../lib/twrk21f120m.iar/debug/bsp; ../../../../../../lib/twrk21f120m.iar/debug/psp
  OBJCOPY.OOCOutputFile: flashx_twrk21f120m_ts.bin
  ILINK.IlinkOutputFile: flashx.out
  ILINK.IlinkIcfFile: C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\mqx\examples\flashx\build\iar\flashx_twrk21f120m_ts\Linker\ts_flash_intflash_a000.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\psp\psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../lib/twrk21f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk21f120m.iar/release/bsp/Sources; ../../../../../../lib/twrk21f120m.iar/release; ../../../../../../lib/twrk21f120m.iar/release/bsp; ../../../../../../lib/twrk21f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk21f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk21f120m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk21f120m.iar/release/psp/psp.a
  group Source
    ../../../: flash_demo_ts.c
