<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\build\iar\bsp_twrk21f120m\bsp_twrk21f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\flashx_twrk21f120m_ts.ewp</path>
  </project>
  <batchBuild/>
</workspace>


