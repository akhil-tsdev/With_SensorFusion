# IAR project spi_SPI0_invensense.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/frdmk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../lib/frdmk22f120m.iar/debug/bsp/Sources; ../../../../../../lib/frdmk22f120m.iar/debug; ../../../../../../lib/frdmk22f120m.iar/debug/bsp; ../../../../../../lib/frdmk22f120m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_SPI0_invensense.srec
  ILINK.IlinkOutputFile: spi.out
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk22f120m.iar/debug/bsp/bsp.a; ../../../../../../lib/frdmk22f120m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/frdmk22f120m.iar/release/bsp/Generated_Code; ../../../../../../lib/frdmk22f120m.iar/release/bsp/Sources; ../../../../../../lib/frdmk22f120m.iar/release; ../../../../../../lib/frdmk22f120m.iar/release/bsp; ../../../../../../lib/frdmk22f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../../../../lib/frdmk22f120m.iar/release/psp/psp.a
  group Source
    ../../../: main.c spi_memory.c spi_memory.h
