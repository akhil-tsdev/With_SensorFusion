# IAR project Backup of hub_prod_2_tasks.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; __ATHEROS_FS__=1; ENABLE_MAG=1; HUB_22F=1; PRODUCTION1=1; EVAL_BOARD=0; TURINGSENSE=1; CPU_MK22FN1M0AVMC12=1; MQX_CPU=PSP_CPU_MK21FN1M; WIFI_DIRECT=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe111,Pe009,Pe550,Pe177,Pe167,Pe301,Pa130,Pe188,Pe520, Pa084,Pa089,Pa118,Pe069,Pe223
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../rtcs/source/include; ../../../shell/source/include; ..\..\..\lib\twrk21f120m.iar\debug\psp; ..\..\..\lib\twrk21f120m.iar\debug\bsp\Sources; ..\..\..\lib\twrk21f120m.iar\debug\bsp\Generated_Code; ..\..\..\lib\twrk21f120m.iar\debug\bsp; ..\..\..\lib\twrk21f120m.iar; C:\turing\Github\trunk\wearable\common_code\include; C:\turing\Github\trunk\wearable\common_code\cbuf; ..\..\..\mqx\source\io\spi_ksdk_1_3_0\include; ..\..\..\turingsense\hub\wmiconfig; ..\..\..\turingsense\hub_multitask\peripheral; ..\..\..\turingsense\hub_multitask\custom; ..\..\..\config\twrk21f120m; ..\..\..\lib\twrk21f120m.iar\debug; ..\..\..\mqx\source\io\spi_ksdk_1_3_0\include\MK22FA12; ..\..\..\mqx\source\io\turingsense; C:\turing\Github\trunk\wearable\nordic_module\hub\RTE\nRF_Libraries\nRF51422_xxAC; C:\turing\github\sdk\cSocket\clientDir; C:\turing\github\trunk\wearable\common_code\hub_22f\cdc\virtual_com; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\lib\twrk21f120m.iar\debug\psp; ..\..\..\lib\twrk21f120m.iar\debug\bsp\Sources; ..\..\..\lib\twrk21f120m.iar\debug\bsp\Generated_Code; ..\..\..\lib\twrk21f120m.iar\debug; ..\..\..\lib\twrk21f120m.iar
  OBJCOPY.OOCOutputFile: hub_prod_2_tasks.bin
  ILINK.IlinkOutputFile: hub_prod_2_tasks.out
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ..\..\..\lib\twrk21f120m.iar\debug\bsp\bsp.a; ..\..\..\lib\twrk21f120m.iar\debug\shell\shell.a; ..\..\..\lib\twrk21f120m.iar\debug\psp\psp.a; ..\..\..\lib\twrk21f120m.iar\debug\rtcs\rtcs.a; ..\..\..\lib\twrk21f120m.iar\debug\mfs\mfs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: NDEBUG; __ATHEROS_FS__=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe111,Pe009,Pe550,Pe177,Pe167,Pe301,Pa130,Pe188,Pe520,Pa084,Pa089, Pa118,Pe069,Pe223
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/throughput_demo/custom; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/frdmk22f120m.iar/release/psp; ../../../lib/frdmk22f120m.iar/release/bsp/Sources; ../../../lib/frdmk22f120m.iar/release/bsp/Generated_Code; ../../../lib/frdmk22f120m.iar/release/bsp; ../../../lib/frdmk22f120m.iar/release
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: throughput_demo.bin
  ILINK.IlinkOutputFile: throughput_demo.out
  ILINK.IlinkIcfFile: ../../../lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/frdmk22f120m.iar/release/bsp/bsp.a; ../../../lib/frdmk22f120m.iar/release/mfs/mfs.a; ../../../lib/frdmk22f120m.iar/release/psp/psp.a; ../../../lib/frdmk22f120m.iar/release/rtcs/rtcs.a; ../../../lib/frdmk22f120m.iar/release/shell/shell.a
  group Source/cbuf
    ../../../../../turing/github/trunk/wearable/common_code/cbuf/: cbuf.c cbuf.h
  group Source/custom
    ../../../turingsense/hub_multitask/custom/: https.c https.h main.h RTCS.c Tasks_multitask.c throughput.h wmiconfig_custom.c
  group Source/custom/crc
    ../../../../../turing/github/trunk/wearable/nordic_module/hub/RTE/nRF_Libraries/nRF51422_xxAC/: crc16.c crc16.h
  group Source/driver_plugin
    ../../../turingsense/hub_multitask/driver_plugin/: atheros_wifi_mediactl_ext.c
  group Source/peripheral
    ../../../turingsense/hub_multitask/peripheral/: atheros_main_loop.c atheros_main_loop.h hub_2_tasks.c hub_main_loop.h hub_to_atheros.c hub_to_atheros.h hub_to_nordic.c hub_to_nordic.h
  group Source/spi
    ../../../mqx/source/io/spi_ksdk_1_3_0/src/: fsl_dspi_common.c fsl_dspi_hal.c fsl_dspi_master_driver.c fsl_dspi_shared_function.c spi_porting_functions.c
  group Source/ts_common
    ../../../../../turing/github/trunk/wearable/common_code/include/: common_err.h common_types.h frame_types.h hub_module.h sat_module.h
  group Source/wmiconfig
    ../../../turingsense/hub/wmiconfig/: wmiconfig_ts.c wmiconfig_ts.h
