# IAR project hub_prod_2_tasks.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; __ATHEROS_FS__=1; ENABLE_MAG=0; HUB_22F=1; PRODUCTION1=1; EVAL_BOARD=0; TURINGSENSE=1; CPU_MK22FN1M0AVMC12=1; MQX_CPU=PSP_CPU_MK21FN1M; WIFI_DIRECT=1; _IAR=1; USE_FLASH=1; PIVOT_TENNIS=1; PIVOT_3_0=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe111,Pe009,Pe550,Pe177,Pe167,Pe301,Pa130,Pe188,Pe520, Pa084,Pa089,Pa118,Pe069,Pe223
  ICCARM.CCIncludePath2: C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/include; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/common_src/include; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/custom_src/include; C:\Freescale\Freescale_MQX_4_1/rtcs/source/include; C:\Freescale\Freescale_MQX_4_1/shell/source/include; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\psp; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Sources; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar; C:\turing\Github\trunk\wearable\common_code\include; C:\turing\Github\trunk\wearable\common_code\cbuf; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\mqx\source\io\spi_ksdk_1_3_0\include; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\turingsense\hub_multitask\wmiconfig; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\turingsense\hub_multitask\peripheral; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\turingsense\hub_multitask\custom; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\config\twrk21f120m; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\mqx\source\io\spi_ksdk_1_3_0\include\MK22FA12; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\mqx\source\io\turingsense; C:\turing\Github\trunk\wearable\nordic_module\hub\RTE\nRF_Libraries\nRF51422_xxAC; C:\turing\github\sdk\cSocket\clientDir; C:\turing\github\trunk\wearable\common_code\hub_22f\cdc\virtual_com; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\usb; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\turingsense\hub_multitask\hub_flash; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\mqx\source\io\turingsense; C:\turing\github\trunk\wearable\common_code\sat_22f\ossf\mpu9250_ossf; C:\turing\github\trunk\wearable\common_code\pivot3_0_poc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\psp; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Sources; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar
  OBJCOPY.OOCOutputFile: SYS_22F_HUB.bin
  ILINK.IlinkOutputFile: SYS_22F_HUB.out
  ILINK.IlinkIcfFile: C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1\demo\hub_prod_2_tasks\Linker\iar\ts_flash_intflash_f000.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\shell\shell.a; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\psp\psp.a; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_1\lib\twrk21f120m.iar\debug\mfs\mfs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: NDEBUG; __ATHEROS_FS__=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe111,Pe009,Pe550,Pe177,Pe167,Pe301,Pa130,Pe188,Pe520,Pa084,Pa089, Pa118,Pe069,Pe223
  ICCARM.CCIncludePath2: C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/include; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/common_src/include; C:\turing\github\trunk\wearable\Freescale\Freescale_MQX_4_1/mqx/source/io/enet/atheros_wifi/custom_src/include; C:\turing\Github\trunk\wearable\Freescale\Freescale_MQX_4_1\turingsense\hub_multitask\custom; C:\Freescale\Freescale_MQX_4_1/rtcs/source/include; C:\Freescale\Freescale_MQX_4_1/shell/source/include; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/psp; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/bsp/Sources; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/bsp/Generated_Code; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/bsp; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: throughput_demo.bin
  ILINK.IlinkOutputFile: throughput_demo.out
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/bsp/bsp.a; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/mfs/mfs.a; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/psp/psp.a; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/rtcs/rtcs.a; C:\Freescale\Freescale_MQX_4_1/lib/frdmk22f120m.iar/release/shell/shell.a
  group Linker
    ../Linker/iar/: intflash.icf ts_flash_intflash_0x13000_DEBUG.icf ts_flash_intflash_f000.icf
  group Source/cbuf
    ../../../../../common_code/cbuf/: cbuf.c cbuf.h
  group Source/custom
    ../../../turingsense/hub_multitask/custom/: adc_ts.c adc_ts.h https.c https.h main.h RTCS.c Tasks_multitask.c throughput.h wmiconfig_custom.c
    ../../../mqx/source/io/turingsense/: ts_io_led.c ts_io_led.h
  group Source/custom/crc
    ../../../../../nordic_module/hub/RTE/nRF_Libraries/nRF51422_xxAC/: crc16.c crc16.h
  group Source/driver_plugin
    ../../../turingsense/hub_multitask/driver_plugin/: atheros_wifi_mediactl_ext.c
  group Source/peripheral
    ../../../turingsense/hub_multitask/peripheral/: atheros_main_loop.c atheros_main_loop.h hub_2_tasks.c hub_main_loop.h hub_to_atheros.c hub_to_atheros.h hub_to_nordic.c hub_to_nordic.h
    ../../../../../common_code/pivot3_0_poc/: pivot3_0_poc.c
  group Source/spi
    ../../../mqx/source/io/spi_ksdk_1_3_0/src/: fsl_dspi_common.c fsl_dspi_hal.c fsl_dspi_master_driver.c fsl_dspi_shared_function.c spi_porting_functions.c
  group Source/ts_common
    ../../../../../common_code/include/: common_err.h common_types.h frame_types.h hub_module.h sat_module.h
  group Source/ts_hub_flash
    ../../../turingsense/hub_multitask/hub_flash/: ts_hub_flash.c ts_hub_flash.h
  group Source/wmiconfig
    ../../../turingsense/hub_multitask/wmiconfig/: wmiconfig_ts.c wmiconfig_ts.h
