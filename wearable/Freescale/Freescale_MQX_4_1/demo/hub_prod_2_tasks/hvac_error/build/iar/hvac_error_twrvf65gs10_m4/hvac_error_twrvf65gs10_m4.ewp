# IAR project hvac_error_twrvf65gs10_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_M4 Freescale VF6xx_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Sources; ../../../../../lib/twrvf65gs10_m4.iar/debug; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp; ../../../../../lib/twrvf65gs10_m4.iar/debug/psp; ../../../../../lib/twrvf65gs10_m4.iar/debug/mfs; ../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs; ../../../../../lib/twrvf65gs10_m4.iar/debug/shell; ../../../../../lib/twrvf65gs10_m4.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_m4.bin
  ILINK.IlinkOutputFile: hvac_error.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/bsp.a; ../../../../../lib/twrvf65gs10_m4.iar/debug/psp/psp.a; ../../../../../lib/twrvf65gs10_m4.iar/debug/mfs/mfs.a; ../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs/rtcs.a; ../../../../../lib/twrvf65gs10_m4.iar/debug/shell/shell.a; ../../../../../lib/twrvf65gs10_m4.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Sources; ../../../../../lib/twrvf65gs10_m4.iar/release; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp; ../../../../../lib/twrvf65gs10_m4.iar/release/psp; ../../../../../lib/twrvf65gs10_m4.iar/release/mfs; ../../../../../lib/twrvf65gs10_m4.iar/release/rtcs; ../../../../../lib/twrvf65gs10_m4.iar/release/shell; ../../../../../lib/twrvf65gs10_m4.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/bsp.a; ../../../../../lib/twrvf65gs10_m4.iar/release/psp/psp.a; ../../../../../lib/twrvf65gs10_m4.iar/release/mfs/mfs.a; ../../../../../lib/twrvf65gs10_m4.iar/release/rtcs/rtcs.a; ../../../../../lib/twrvf65gs10_m4.iar/release/shell/shell.a; ../../../../../lib/twrvf65gs10_m4.iar/release/usb/usbh.a
  group Source
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h usb_classes.c usb_classes.h
