# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\STM32F4xx_HAL_Driver\Inc; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\STM32F4xx-Nucleo; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\X_NUCLEO_IKS01A2; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\Components\Common; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\Components\hts221; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\Components\lps22hb; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\Components\lsm6dsl; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\BSP\Components\lsm303agr; C:\turing\github\trunk\wearable\STM\en.x-cube-mems1\STM32CubeExpansion_MEMS1_V4.1.0\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
  group Drivers/BSP/STM32F4xx-Nucleo
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/turing/github/trunk/wearable/STM/en.x-cube-mems1/STM32CubeExpansion_MEMS1_V4.1.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: com.c cube_hal_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
