# Keil uVision project radio_test_spi_slave.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: radio_test_spi_slave +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_CUSTOM PRINTF_UNSAFE EVAL_BOARD=0 PRODUCTION1=1 HUB_NORDIC=1
  c misc: --c99
  c include: ..\..;..\..\..\..\..\..\..\common_code\diag\radio_test;..\..\..\..\ts_radio_dtm\ts_radio_dtm\common\hub_board\;..\..\..\common\
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: radio_test.c radio_test.h main_radio_test_spi_slave.c main_radio_test_spi_slave.h spi_slave_radio_test.c spi_slave_radio_test.h
    ../../../../../../../common_code/diag/radio_test/: radio_test_common_types.h
  group Documentation
    ../../: Abstract.txt license.txt
software components: CMSIS:CORE 3.40.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:spi_slave 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:crc16 2.0.0, nRF_Libraries:retarget 2.0.0
