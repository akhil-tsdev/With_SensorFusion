# Keil uVision project direct_test_mode_turingsense.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c misc: --c99
  c include: ..\..\..;.\RTE\nRF_BLE\nRF51422_xxAC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
    ./RTE/nRF_BLE/nRF51422_xxAC/: simple_uart.c simple_uart.h
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    RTE/nRF_BLE/nRF51422_xxAC/: ble_dtm.c ble_dtm.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_dtm 2.0.0, nRF_Drivers:nrf_gpio 2.0.0
