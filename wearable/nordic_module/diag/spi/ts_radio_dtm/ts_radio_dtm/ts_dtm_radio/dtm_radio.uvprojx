# Keil uVision project dtm_radio.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_PCA10028 SPI_MASTER_0_ENABLE CB_SIZE=8 CB_TYPE=sat_cbuf_packet_t SAT_NORDIC=1  ENABLE_MAG=1
  c misc: --c99
  c include: ..\common;..\..\common_code\include;..\..\common_code\cbuf;..\common\uesb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: dtm_radio_main.c
    ../common/: net_common.c net_common.h crc32.c
    ../common/uesb/: micro_esb.c
    ./: ts_spi_master.c ts_radio_dtm_function.c
    ../../common_code/cbuf/: cbuf.c cbuf.h
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:nrf_soc 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Drivers:spi_master 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:crc16 1.1.0, nRF_Libraries:nrf_assert 1.1.0
