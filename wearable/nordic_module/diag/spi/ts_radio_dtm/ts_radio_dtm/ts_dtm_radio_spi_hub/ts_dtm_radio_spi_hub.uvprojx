# Keil uVision project ts_dtm_radio_spi_hub.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: DTM_NRD_HUB +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_CUSTOM CB_SIZE=80 CB_TYPE=sat_sensor_record_t PRINTF_UNSAFE EVAL_BOARD=0 PRODUCTION1=1 ENABLE_MAG=0 HUB_NORDIC=1
  c misc: --c99
  c include: ..\common;..\..\common_code\include;..\..\common_code\cbuf;..\..\..\..\..\..\common_code\diag\dtm\common;..\common\uesb;..\common\hub_board;..\ts_dtm_radio_spi_hub;..\common\dtm_common
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application
    ../common/: net_common.c crc32.c
    ../common/uesb/: micro_esb.c
    ../../common_code/cbuf/: cbuf.c
    ./: spi_slave_comm_dtm.c hub_main_dtm.c
    ../../../../../../common_code/diag/dtm/common/: dtm_common_types.h
    ../common/dtm_common/: ts_radio_dtm_function.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: nrf_soc.c simple_uart.c simple_uart.h spi_slave.c spi_slave.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_util_platform.c crc16.c crc16.h nrf_assert.c nrf_assert.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 7.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:nrf_soc 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Drivers:spi_slave 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:crc16 1.1.0, nRF_Libraries:nrf_assert 1.1.0
