# Keil uVision project hub_not_talking_to_22f_pivot3_0_poc.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_CUSTOM CB_SIZE=90 CB_TYPE=sat_sensor_record_t PRINTF_UNSAFE EVAL_BOARD=1 NO22F=1 PRODUCTION1=0 ENABLE_MAG=0 HUB_NORDIC=1 PIVOT_3_0=1
  c misc: --c99
  c include: ..\..\..\common;..\..\..\..\common_code\include;..\..\..\..\common_code\cbuf;..\hub_standalone;..\..\..\common\hub_board;..\..\..\..\common_code\pivot3_0_poc;..\hub_not_talking_to_22f_pivot3_0_poc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: hub_main.c
    ./: spi_slave_comm.c hub_timer.c
    ../../../common/: net_common.c crc32.c
    ../../../common/uesb/: micro_esb.c
    ../../../../common_code/cbuf/: cbuf.c
    ../../../../common_code/pivot3_0_poc/: pivot3_0_poc.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: simple_uart.c simple_uart.h spi_slave.c spi_slave.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_util_platform.c crc16.c crc16.h nrf_assert.c nrf_assert.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 7.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Drivers:spi_slave 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:crc16 1.1.0, nRF_Libraries:nrf_assert 1.1.0
