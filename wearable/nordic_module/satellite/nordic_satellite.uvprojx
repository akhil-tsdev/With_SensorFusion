# Keil uVision project nordic_satellite.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: SYS_NRD_SAT +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_PCA10028 SPI_MASTER_0_ENABLE SAT_NORDIC=1  ENABLE_MAG=0 KSDK_1_0_0=1 PV900_DISABLE=0 TURINGSENSE=1 PIVOT_3_0=1
  c misc: --c99
  c include: ..\common;..\..\common_code\include;..\..\common_code\cbuf;..\..\common_code\pivot3_0_poc;..\satellite;..\..\common_code\sat_22f\OSSF\mpu9250_ossf\
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x1c800
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application
    ./: satellite_main.c
    ../common/: net_common.c net_common.h crc32.c
    ../common/uesb/: micro_esb.c
    ./: ts_spi_master.c satellite_main.h rfcbuf.c rfcbuf.h hub_timer.c hub_timer.h
    ../../common_code/cbuf/: cbuf.c cbuf.h
    ../../common_code/pivot3_0_poc/: pivot3_0_poc.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: nrf_soc.c simple_uart.c simple_uart.h spi_master.c spi_master.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h app_util_platform.c crc16.c crc16.h nrf_assert.c nrf_assert.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:nrf_soc 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Drivers:spi_master 1.2.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:crc16 1.1.0, nRF_Libraries:nrf_assert 1.1.0
